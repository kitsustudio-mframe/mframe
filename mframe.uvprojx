# Keil uVision project mframe.uvprojx, settings and files
target cm0 (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: mframe_cm0 (library)
  AfterMake: cmd.exe /C copy .keil\cm0\Objects\mframe_cm0.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group root
    ./: mframe.h package-info.h
  group root/ctrl
    ./ctrl/: package-info.h Ammeter.cpp Ammeter.h SerialPort.cpp SerialPort.h SerialPortInputStream.cpp SerialPortInputStream.h SerialPortOutputStream.cpp SerialPortOutputStream.h TemperatureSensor.h Voltmeter.cpp Voltmeter.h
  group root/ctrl/virt
    ./ctrl/virt/: package-info.h VirtualAnalogInputPin.cpp VirtualAnalogInputPin.h VirtualGeneralPin.cpp VirtualGeneralPin.h VirtualTemperatureSensor.cpp VirtualTemperatureSensor.h
  group root/hal
    ./hal/: package-info.h AnalogInputPin.h AnalogInputPort.h Base.h GeneralInput.h GeneralOutput.h GeneralPin.h GeneralPinMode.h GeneralPort.h InterruptEvent.h
  group root/hal/timer
    ./hal/timer/: package-info.h EventCancel.h EventTrigger.h Timer.h
  group root/hal/trigger
    ./hal/trigger/: package-info.h EdgeTrigger.h EventFall.h EventRise.h
  group root/hal/usart
    ./hal/usart/: package-info.h EventReceiver.h EventTransfer.h USART.h
  group root/io
    ./io/: package-info.h Buffer.h ByteBuffer.cpp ByteBuffer.h Closeable.h CompletionHandler.h Echoable.h EmptyReadBuffer.cpp EmptyReadBuffer.h EmptyWriteBuffer.cpp EmptyWriteBuffer.h InputStream.cpp InputStream.h InputStreamBuffer.cpp InputStreamBuffer.h InputStreamWriteBuffer.cpp InputStreamWriteBuffer.h OutputStream.cpp OutputStream.h OutputStreamBuffer.cpp OutputStreamBuffer.h OutputStreamReadBuffer.cpp OutputStreamReadBuffer.h PrintBuffer.cpp PrintBuffer.h ReadBuffer.h ReadBufferMonitor.cpp ReadBufferMonitor.h ReadOnlyBuffer.cpp ReadOnlyBuffer.h RingBuffer.cpp RingBuffer.h StreamSkipper.cpp StreamSkipper.h WriteBuffer.h WriteBufferMonitor.cpp WriteBufferMonitor.h
  group root/lang
    ./lang/: Character.cpp Character.h Class.h Data.cpp Data.h Executor.h Hashcode.cpp Hashcode.h HashGenerator.cpp HashGenerator.h Interface.h Iterable.h Maths.cpp Maths.h Memory.cpp Memory.h Object.cpp Object.h package-info.h Pointer.cpp Pointer.h Pointers.cpp Pointers.h StringFormat.cpp StringFormat.h Strings.cpp Strings.h System.cpp System.h
  group root/lang/func
    ./lang/func/: BiConsumer.h BiConsumerEvent.h BiConsumerMethod.h Consumer.h ConsumerEvent.h ConsumerMethod.h Function.h FunctionEvent.h FunctionMethod.h package-info.h Runnable.h RunnableEntity.cpp RunnableEntity.h RunnableEvent.cpp RunnableEvent.h RunnableMethod.h Supplier.h SupplierEvent.h SupplierMethod.h
  group root/lang/numb
    ./lang/numb/: Boolean.cpp Boolean.h Booleans.cpp Booleans.h Byte.cpp Byte.h Bytes.cpp Bytes.h Integer.cpp Integer.h Integers.cpp Integers.h Number.cpp Number.h package-info.h Short.cpp Short.h Shorts.cpp Shorts.h
  group root/lang/sys
    ./lang/sys/: Allocator.h DefaultAllocator.cpp DefaultAllocator.h EntryPoint.cpp EntryPoint.h ErrorCode.h HardwareInfo.h Kernel.h package-info.h Stacker.cpp Stacker.h Svchost.cpp Svchost.h SystemConfig.h SystemControl.h Thread.cpp Thread.h ThreadPriority.h ThreadState.h Timer.cpp Timer.h
  group root/util
    ./util/: Array.h ArrayMap.h ArrayMapPrototype.cpp ArrayMapPrototype.h ArrayPrototype.cpp ArrayPrototype.h ArrayQueue.h ArrayQueuePrototype.cpp ArrayQueuePrototype.h Base64.cpp Base64.h Collection.h CommandExecutor.cpp CommandExecutor.h CommandHandler.h CommandHandlerDefaultHelp.cpp CommandHandlerDefaultHelp.h CommandHandlerEvent.cpp CommandHandlerEvent.h CommandHandlerMethod.h Future.cpp Future.h Iterator.h Map.h package-info.h Pool.h Queue.h Scanner.cpp Scanner.h Updater.h
target cm3 (6180000::V6.18::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: mframe_cm3 (library)
  AfterMake: cmd.exe /C copy .keil\cm3\Objects\mframe_cm3.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target cm4f (6180000::V6.18::ARMCLANG)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: mframe_cm4f (library)
  AfterMake: cmd.exe /C copy .keil\cm4f\Objects\mframe_cm4f.lib .\
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
